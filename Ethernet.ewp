# IAR project Ethernet.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VE ST STM32F103VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD
  ICCARM.CCIncludePath2: $PROJ_DIR$; vectors; STM32F10x_Drivers_Lib\CMSIS\CM3\CoreSupport; STM32F10x_Drivers_Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; STM32F10x_Drivers_Lib\inc; ethernet
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: Ethernet.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group (top)
    ./: main.cpp
  group Net
    ethernet/: enc28j60.cpp ethernet.cpp
  group STM32F10x_Drivers_Lib
    STM32F10x_Drivers_Lib/src/: exti.cpp gpio.cpp interrupt.cpp rtc.cpp spi.cpp systick.cpp uart.cpp watchdog.cpp
  group System
    STM32F10x_Drivers_Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group System/Startup
    STM32F10x_Drivers_Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group Vectors
    vectors/: stm32f10x_it.c stm32f10x_it.h
